# Keil uVision project SW_SLJ_20260413.uvprojx, settings and files
target SW_SLJ (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: GD32F303CC GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.3.0
  cpu: IROM(0x08000000,0x040000) IRAM(0x20000000,0x0C000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: SW_SLJ_20260413 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F30X_HD
  c include: ..\Drivers\CMSIS;..\Drivers\CMSIS\GD\GD32F30x\Include;..\Drivers\GD32F30x_standard_peripheral\Include;..\Drivers\gd32f303xx_bsp;..\Drivers\SYSTEM;..\User;..\Drivers\usbd_lib\device\Include;..\Drivers\usbd_lib\usbd\Include;..\Drivers\usbd_lib\class\device\hid\Include;..\Application\Dispaly_menu;..\Application\Key_control;..\Application\Rs485_rtu;..\Application\Rs485_tcp
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Startup
    ../Drivers/CMSIS/GD/GD32F30x/Source/ARM/: startup_gd32f30x_hd.s
  group User
    ../Drivers/CMSIS/GD/GD32F30x/Source/: system_gd32f30x.c
    ../User/: gd32f30x_it.c main.c
  group Drivers/GD32F30x_standard_peripheral
    ../Drivers/GD32F30x_standard_peripheral/Source/: gd32f30x_adc.c gd32f30x_bkp.c gd32f30x_can.c gd32f30x_crc.c gd32f30x_ctc.c gd32f30x_dac.c gd32f30x_dbg.c gd32f30x_dma.c gd32f30x_enet.c gd32f30x_exmc.c gd32f30x_exti.c gd32f30x_fmc.c gd32f30x_fwdgt.c gd32f30x_gpio.c gd32f30x_i2c.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_rtc.c gd32f30x_sdio.c gd32f30x_spi.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_wwdgt.c
  group Drivers/gd32f303xx_bsp
    ../Drivers/gd32f303xx_bsp/: bll_bgp.c bsp.c bsp_assert.c bsp_atbm6431.c bsp_fifo.c bsp_gd32f30x_adc.c bsp_gd32f30x_hhctl.c bsp_gd32f30x_rcu.c bsp_gd32f30x_rtc.c bsp_gd32f303xx.c bsp_gd32f303xx_jlx192128g.c bsp_gd32f303xx_mbboard.c bsp_gd32f303xx_mbuser.c bsp_gd32f303xx_modbus.c bsp_gd32f303xx_systick.c bsp_hhctl_pwr.c bsp_i2c_gd32f30x.c bsp_malloc.c bsp_modbus_tcp.c bsp_stamach.c bsp_wifi.c bsp_wifi_trans.c drv_hid.c drv_pm.c bsp_drdusb.c
  group Application/rs485_tcp
    ../Application/Rs485_tcp/: user_variables.c
software components: CMSIS:CORE 6.1.0
